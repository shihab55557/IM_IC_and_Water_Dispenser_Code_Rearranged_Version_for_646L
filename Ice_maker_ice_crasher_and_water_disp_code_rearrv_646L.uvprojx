# Keil uVision project Ice_maker_ice_crasher_and_water_disp_code_rearrv_646L.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Ice_maker_ice_crasher_and_water_disp_code_rearrv_646L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Source Group 1
    ./: main.c Uart.c Uart.h Icemaker.c Icemaker.h timer.c timer.h Debug_data.c Debug_data.h ntc.c ntc.h iirlpf.c iirlpf.h disp.c disp.h disp_comm.c disp_comm.h timebase.c timebase.h crc.c crc.h water_dispenser.c water_dispenser.h Parameter.c Parameter.h debug_parameter.c debug_parameter.h glvars.c glvars.h User_config.c User_config.h auger_motor.c auger_motor.h flapper_motor.c flapper_motor.h ice_type.c ice_type.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.4.2
